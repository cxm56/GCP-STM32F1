# IAR project GCP.ewp, settings and files
configuration STM32F1 (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103CB ST STM32F103CB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCDiagSuppress: pa082
  ICCARM.CCIncludePath2: ../SysCore/Core; ../SysCore/Drivers
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stm32f0xx.bin
  ILINK.IlinkOutputFile: GCP.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group ALG
    ../ALG/: crc16.c crc8.c
  group Application
    ../Application/: GC_ComMan.c GC_ComMan.h GC_CtrlIOTable.c GC_CtrlIOTable.h GC_HardwareDef.h GC_HwCtrl.c GC_HwCtrl.h GC_MainProc.c GC_MainProc.h
  group DataType
    ../DataType/: DataType.h
  group Main
    ../Main/: Main.c
  group PeriDrivers/Ammeter
    ../PeriDrivers/Ammeter/: Ammeter_Spm91.c Ammeter_Spm91.h
  group PeriDrivers/Eeprom
    ../PeriDrivers/Eeprom/: at24cxx.c at24cxx.h Eeprom.c Eeprom.h
  group PeriDrivers/LCD
    ../PeriDrivers/LCD/: LCD1602.c LCD1602.h
  group PeriDrivers/NixieTube
    ../PeriDrivers/NixieTube/: NixieTube.c NixieTube.h TM1617.c TM1617.h
  group SysCore/Core
    ../SysCore/Core/: chip.h ring_buffer.c ring_buffer.h stm32f10x.h stm32f10x_conf.h system_stm32f10x.c system_stm32f10x.h
  group SysCore/Drivers
    ../SysCore/Drivers/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group SysCore/Startup
    ../SysCore/Startup/: startup_stm32f10x_hd.s
  group SysInit
    ../SysInit/: SYS_Init.c SYS_Init.h
  group SysPeripheral
    ../SysPeripheral/: Demo.c Demo.h
  group SysPeripheral/EXTI
    ../SysPeripheral/EXTI/: EXTI.c EXTI.h
  group SysPeripheral/GPIO
    ../SysPeripheral/GPIO/: GPIO_Man.c GPIO_Man.h
  group SysPeripheral/HAL
    ../SysPeripheral/HAL/: HAL_Exti.c HAL_Exti.h HAL_Gpio.c HAL_Gpio.h HAL_IRQHandler.c HAL_IRQHandler.h HAL_Spi.c HAL_Spi.h HAL_SysCtrl.c HAL_SysCtrl.h HAL_SysInit.c HAL_SysInit.h HAL_SysTick.c HAL_SysTick.h HAL_TimeComm.c HAL_TimeComm.h HAL_TimeDelay.c HAL_TimeDelay.h HAL_TimeInput.c HAL_TimeInput.h HAL_TimeOutput.c HAL_TimeOutput.h HAL_Uart.c HAL_Uart.h HAL_Watchdog.c HAL_Watchdog.h ReadMe.txt
  group SysPeripheral/I2C
    ../SysPeripheral/I2C/: I2C_BaseOps.c I2C_DataStructDef.h I2C_DeviceAPI.c I2C_DeviceOps.c I2C_Interface.h
  group SysPeripheral/IRQ
    ../SysPeripheral/IRQ/: IRQ_Man.c IRQ_Man.h
  group SysPeripheral/KEY
    ../SysPeripheral/KEY/: KEY.c KEY.h
  group SysPeripheral/SysCtrl
    ../SysPeripheral/SysCtrl/: SysCtrl.c SysCtrl.h
  group SysPeripheral/SysTick
    ../SysPeripheral/SysTick/: SysTick.c SysTick.h SysTimer.c SysTimer.h
  group SysPeripheral/UART
    ../SysPeripheral/UART/: UART.c UART.h UartDataStructDef.h UartInterface.c UartInterface.h ucom.c ucom.h
  group Version
    ../Version/: VER_DataStructDef.h Version.h
